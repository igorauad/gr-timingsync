options:
  parameters:
    author: Igor Freire (igorfreire@ufpa.br)
    description: Evaluates the timing alignment error between the signals received from two RF interfaces based on the peak of their cross-correlation.
    generate_options: no_gui
    id: timing_analyzer
    output_language: python
    run_options: run
    title: Correlator-based Timing Alignment Analyzer
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: corr_fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: cp_duration_us
  id: variable
  parameters:
    value: cp_len * (1/samp_rate) * 1e6
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: n_plot_points
  id: variable
  parameters:
    value: int(samp_rate * 0.0005/7)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7.68e6
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: address
  id: parameter
  parameters:
    label: USRP address
    short_id: a
    type: str
    value: '"serial=30E8A70"'
  states: {}
- name: blocks_complex_to_mag_1_0
  id: blocks_complex_to_mag
  parameters:
    vlen: corr_fft_len
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: timing_results.dat
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: '1'
    type: float
    vlen: corr_fft_len
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: corr_fft_len
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: corr_fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: corr_fft_len
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: corr_fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(corr_fft_len)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: corr_fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(corr_fft_len)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: corr_fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(corr_fft_len)
  states: {}
- name: freq
  id: parameter
  parameters:
    label: RF center frequency.
    short_id: f
    type: eng_float
    value: 2.45e9
  states: {}
- name: gain
  id: parameter
  parameters:
    label: USRP gain
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: log
  id: parameter
  parameters:
    label: 'Interval of periodic cross-correlation peak index logs (default: 0.0)'
    short_id: l
    type: eng_float
    value: '0.0'
  states: {}
- name: rfs_argmax_0
  id: rfs_argmax
  parameters:
    vlen: corr_fft_len
  states: {}
- name: rfs_wrap_fft_index_ss_0
  id: rfs_wrap_fft_index_ss
  parameters:
    fft_size: corr_fft_len
    log_per: log
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: address
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    otw: sc16
    samp_rate: samp_rate
    stream_chans: ''
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_1_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', rfs_argmax_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_1, '0']
- [blocks_short_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_1_0, '0']
- [rfs_argmax_0, '0', rfs_wrap_fft_index_ss_0, '0']
- [rfs_wrap_fft_index_ss_0, '0', blocks_null_sink_0, '0']
- [rfs_wrap_fft_index_ss_0, '0', blocks_short_to_float_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
