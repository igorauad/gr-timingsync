options:
  parameters:
    author: Igor Freire (igorfreire@ufpa.br)
    description: Evaluates the timing alignment error between the signals received from two RF interfaces based on the peak of their cross-correlation.
    generate_options: qt_gui
    id: timing_analyzer_gui
    output_language: python
    title: Correlator-based Timing Alignment Analyzer
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: corr_fft_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: cp_duration_us
  id: variable
  parameters:
    value: cp_len * (1/samp_rate) * 1e6
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: misalignment_us
  id: variable
  parameters:
    value: misalignment * (1/samp_rate) * 1e6
  states: {}
- name: n_plot_points
  id: variable
  parameters:
    value: int(samp_rate * 0.0005/7)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7.68e6
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0
    label: 'NOTE:'
    type: string
    value: negative values (Ch2 lagging Ch1) wrap to last FFT bins
  states: {}
- name: address
  id: parameter
  parameters:
    label: USRP address
    short_id: a
    type: str
    value: '"serial=30E8A70"'
  states: {}
- name: blocks_complex_to_mag_1_0
  id: blocks_complex_to_mag
  parameters:
    vlen: corr_fft_len
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: timing_results.dat
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: '1'
    type: float
    vlen: corr_fft_len
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: corr_fft_len
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: corr_fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: corr_fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: corr_fft_len
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: corr_fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(corr_fft_len)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: corr_fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(corr_fft_len)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: corr_fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(corr_fft_len)
  states: {}
- name: freq
  id: parameter
  parameters:
    label: RF center frequency.
    short_id: f
    type: eng_float
    value: 2.45e9
  states: {}
- name: gain
  id: parameter
  parameters:
    label: USRP gain
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: misalignment
  id: parameter
  parameters:
    label: Misalignment in samples to set between waveforms in simulation.
    value: '50'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: corr_fft_len
    name: '"Histogram"'
    size: '1024'
    type: float
    xmax: corr_fft_len/2
    xmin: '-corr_fft_len/2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,0
    name: '"Cross-correlation"'
    size: corr_fft_len
    srate: samp_rate
    tr_delay: '10e-6'
    tr_tag: '"sync_start"'
    type: float
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0
    name: '"Cross-correlation Peak Index"'
    size: 20*int(samp_rate/corr_fft_len)
    srate: samp_rate/corr_fft_len
    type: float
    update_time: '0.5'
    ylabel: Index
  states: {}
- name: rfs_argmax_0
  id: rfs_argmax
  parameters:
    vlen: corr_fft_len
  states: {}
- name: rfs_wrap_fft_index_ss_0
  id: rfs_wrap_fft_index_ss
  parameters:
    fft_size: corr_fft_len
    log_per: '0.0'
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: RX2
    center_freq0: freq
    center_freq1: freq
    clock_rate: '0.0'
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: address
    dev_args: '""'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    otw: sc16
    samp_rate: samp_rate
    stream_chans: ''
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_1_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_moving_average_xx_0, '0', rfs_argmax_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_1, '0']
- [blocks_short_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_short_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', blocks_complex_to_mag_1_0, '0']
- [rfs_argmax_0, '0', rfs_wrap_fft_index_ss_0, '0']
- [rfs_wrap_fft_index_ss_0, '0', blocks_short_to_float_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
